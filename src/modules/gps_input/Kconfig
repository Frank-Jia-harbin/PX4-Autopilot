## src/modules/gps_input/Kconfig
```kconfig
menuconfig MODULES_GPS_INPUT
	bool "gps_input"
	default n
	---help---
		Enable support for gps_input
```
